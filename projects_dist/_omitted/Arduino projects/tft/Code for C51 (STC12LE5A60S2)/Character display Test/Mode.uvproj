# Keil uVision project Mode.uvproj, settings and files
target Target 1 (MCS-51)
  device: W78E516B Winbond
  cpu: IRAM(0 - 0xFF) XRAM(0- 0xFF) IROM(0-0xFFFF) CLOCK(40000000)
  output: SPI +hex
  c flags: Optimize=8 SizeSpeed=1
  group Main
    ./Program/: 282838p.c
